FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://psplash-cutera-img.png"

SPLASH_IMAGES = "file://psplash-cutera-img.png;outsuffix=default"
