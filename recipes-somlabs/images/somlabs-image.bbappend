IMAGE_FEATURES:append = "splash"

IMAGE_INSTALL:append = " lsof v4l-utils ffmpeg \
util-linux  libcamera gstreamer1.0 libcamera-gst \
gstreamer1.0-plugins-base \
packagegroup-core-tools-debug yavta \
scythe-cutera-app \
"
