require recipes-kernel/linux/linux-imx-emsyslabs-src.inc
